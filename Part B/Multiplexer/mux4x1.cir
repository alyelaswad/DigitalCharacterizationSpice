*MUX4X1
.include MOSFET_models_0p5_0p18-1.inc
VDD VDD 0 DC 1.8
V0 D0 0 PULSE(1.8 0 0 1n 1n 1n 5n)
V1 D1 0 PULSE(0 1.8 0 1n 1n 1n 5n)
V2 D2 0 PULSE(0 1.8 0 1n 1n 1n 5n)
V3 D3 0 PULSE(0 1.8 0 1n 1n 1n 5n)
VS1 S1 0 PULSE(1.8 0 0 1n 1n 1n 5n)
VS0 S0 0 PULSE(0 1.8 0 1n 1n 1n 5n)

*Inverters
Mp1 D0_inv D0 VDD VDD PMOS0P18 [w=1.8u l=0.18u as=0.972p ad=0.972p ps=4.68u pd=4.68u]
Mn1 D0_inv D0 0 0 NMOS0P18 [w=0.9u l=0.18u as=0.486p ad=0.486p ps=2.88u pd=2.88u]

Mp2 D1_inv D1 VDD VDD PMOS0P18 [w=1.8u l=0.18u as=0.972p ad=0.972p ps=4.68u pd=4.68u]
Mn2 D1_inv D1 0 0 NMOS0P18 [w=0.9u l=0.18u as=0.486p ad=0.486p ps=2.88u pd=2.88u]

Mp3 D2_inv D2 VDD VDD PMOS0P18 [w=1.8u l=0.18u as=0.972p ad=0.972p ps=4.68u pd=4.68u]
Mn3 D2_inv D2 0 0 NMOS0P18 [w=0.9u l=0.18u as=0.486p ad=0.486p ps=2.88u pd=2.88u]

Mp4 D3_inv D3 VDD VDD PMOS0P18 [w=1.8u l=0.18u as=0.972p ad=0.972p ps=4.68u pd=4.68u]
Mn4 D3_inv D3 0 0 NMOS0P18 [w=0.9u l=0.18u as=0.486p ad=0.486p ps=2.88u pd=2.88u]

Mp5 S0_inv S0 VDD VDD PMOS0P18 [w=1.8u l=0.18u as=0.972p ad=0.972p ps=4.68u pd=4.68u]
Mn5 S0_inv S0 0 0 NMOS0P18 [w=0.9u l=0.18u as=0.486p ad=0.486p ps=2.88u pd=2.88u]

Mp6 S1_inv S1 VDD VDD PMOS0P18 [w=1.8u l=0.18u as=0.972p ad=0.972p ps=4.68u pd=4.68u]
Mn6 S1_inv S1 0 0 NMOS0P18 [w=0.9u l=0.18u as=0.486p ad=0.486p ps=2.88u pd=2.88u]

*PUN
M1 DP1 D0_inv VDD VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]
M2 DP2 D1_inv VDD VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]
M3 DP3 D2_inv VDD VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]
M4 DP4 D3_inv VDD VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]
M5 DP5 S1 DP1 VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]
M6 DP6 S1_inv DP2 VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]
M7 DP7 S1 DP3 VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]
M8 DP8 S1_inv DP4 VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]
M9 Y S0 DP5 VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]
M10 Y S0 DP6 VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]
M11 Y S0_inv DP7 VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]
M12 Y S0_inv DP8 VDD PMOS0P18 [w=5.4u l=0.18u as=2.916p ad=2.916p ps=11.88u pd=11.88u]

*PDN
M13 Y D0_inv DN1 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]
M14 Y S1 DN1 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]
M15 Y S0 DN1 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]
M16 DN1 D1_inv DN2 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]
M17 DN1 S1_inv DN2 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]
M18 DN1 S0 DN2 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]
M19 DN2 D2_inv DN3 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]
M20 DN2 S1 DN3 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]
M21 DN2 S0_inv DN3 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]
M22 DN3 D3_inv 0 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]
M23 DN3 S1_inv 0 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]
M24 DN3 S0_inv 0 0 NMOS0P18 [w=3.6u l=0.18u as=1.944p ad=1.944p ps=8.28u pd=8.28u]

*Propagation Delay
.measure TRAN tPLH TRIG V(D1) VAL=0.9 RISE=1 TARG V(Y) VAL=0.9 RISE=1
.measure TRAN tPHL TRIG V(D1) VAL=0.9 FALL=1 TARG V(Y) VAL=0.9 FALL=1

*Average Power Dissipation
.measure tran totalPower INTEG (V(Vdd)*Is(M2))
.measure tran averagePower param = totalPower/100u

.tran 1n 100u
.END
